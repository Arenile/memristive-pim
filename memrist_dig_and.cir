* SPICE netlist generated by Yosys 0.24+10 (git sha1 3ebc50dee, clang 10.0.0-4ubuntu1 -fPIC -Os)

X0 mid out memristor
X1 a mid memristor
X2 b mid memristor

************************
* end of SPICE netlist *
************************
